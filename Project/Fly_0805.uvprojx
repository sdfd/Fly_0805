# Keil uVision project Fly_0805.uvprojx, settings and files
target Fly_0805 (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fly_0805
  c flags: Optim=1 uC99=1 wLevel=2
  c define: rvmdk TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PGE
  c include: ..\APP;..\Driver;..\Sys;..\inc;..\driverlib;..\grlib;..\sensorlib;..\utils;..\;.\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sys
    ../Sys/: main.c SysConfig.h Interrupt.c
  group APP
    ../APP/: Control.c Control.h IMU.c IMU.h Data_Transfer.h Rc.c Rc.h Data_Transfer.c
  group Driver
    ../Driver/: PWM_Out.c PWM_Out.h time_systick.h time_systick.c nRF24L01.c nRF24L01.h LED.c LED.h User_UART.c User_UART.h Int_0_5ms.c Int_0_5ms.h Tim_pwm_in.c Tim_pwm_in.h
    ../APP/: User_MPU6050.c User_MPU6050.h
  group Lib
    ../sensorlib/: i2cm_drv.c mpu6050.c
    ../driverlib/rvmdk/: driverlib.lib
  group ::Device
    RTE/Device/TM4C123GH6PGE/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
